options:
  parameters:
    author: dragon
    generate_options: qt_gui
    id: demod101
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '40'
  states: {}
- name: frequency_shift
  id: variable_qtgui_range
  parameters:
    start: '-145e3'
    step: '100'
    stop: '-135e3'
    value: '-140e3'
  states: {}
- name: num_symbols
  id: variable
  parameters:
    value: (stop_time - start_time) * symbol_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: start_time
  id: variable
  parameters:
    comment: in seconds
    value: '4.34'
  states: {}
- name: stop_time
  id: variable
  parameters:
    comment: in seconds
    value: '4.87'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 1.2e3
  states: {}
- name: variable_low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 10e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: |-
      1111 1111 in binary with two's complement
      flips all bits in case the graph acquired the wrong symbol
    const: '-1'
    type: byte
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Answer should be:
      Looks like you got it! This is Demod 101 part 3. flag{its_ju5t_a_ph4Se}
    file: /tmp/test.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test2.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dragon/Documents/GNU-Radio-Conference-2023-CTF/Demod101/demod.sigmf-data
    length: int((stop_time - start_time) * samp_rate)
    offset: int(start_time * samp_rate)
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: (2 * math.pi) / 100
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Input Rate: samp_rate / decimation
      Output Rate: symbol_rate
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: int((samp_rate / decimation) / symbol_rate)
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Custom Decoding',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param
              self.key = pmt.intern("frame_start")
              self.message = []
              self.message_threshold = 750 # slightly more bits than are contained in the message

          def work(self, input_items, output_items):
              # demod
              bits = [1 if np.real(samp) > 0 else -1 for samp in input_items[0]]
              output_items[0][:] = bits

              self.message = self.message + bits
              if(len(self.message) > self.message_threshold):

                  # find start of frame
                  start_code = [1, -1] * 14
                  threshold = 25 # max achievable threshold is 28 (i.e. length of start code)
                  correlation = np.correlate(start_code, self.message)
                  indices = np.where(correlation > threshold)[0]
                  if(len(indices) >= 1):
                      self.add_item_tag(0, self.nitems_written(0) + indices[0], self.key, pmt.intern(str(correlation[indices[0]])))
                  print(len(correlation))

                  # print out message and reset length
                  self.message = []
              
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: frequency_shift
    comment: |-
      Input Rate: samp_rate
      Output Rate: samp_rate / decimation
    decim: decimation
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"AFTER costas loop"'
    size: int((stop_time - start_time) * symbol_rate)
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"BEFORE RRC"'
    size: int((stop_time - start_time) * (samp_rate / decimation))
    srate: samp_rate / decimation
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"AFTER symbol sync"'
    size: int((stop_time - start_time) * symbol_rate)
    srate: symbol_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"AFTER costas loop"'
    size: int((stop_time - start_time) * symbol_rate)
    srate: symbol_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"AFTER costas loop"'
    size: int((stop_time - start_time) * symbol_rate)
    srate: symbol_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"AFTER RRC"'
    size: int((stop_time - start_time) * (samp_rate / decimation))
    srate: samp_rate / decimation
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '2.5'
    ntaps: '110'
    samp_rate: samp_rate / decimation
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '1']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_xor_xx_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_xor_xx_0, '0', blocks_file_sink_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', epy_block_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_0, '0', blocks_complex_to_real_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
