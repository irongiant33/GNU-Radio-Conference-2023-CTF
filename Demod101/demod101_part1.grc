options:
  parameters:
    author: dragon
    generate_options: qt_gui
    id: demod101
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '40'
  states: {}
- name: frequency_shift
  id: variable_qtgui_range
  parameters:
    start: '-240e3'
    step: 1e3
    stop: 240e3
    value: 15.56e3
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    comment: from frequency sink analysis
    value: 2.4e3
  states: {}
- name: max_pdu_size
  id: variable
  parameters:
    value: int((stop_time - start_time) * (samp_rate / decimation))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: start_time
  id: variable
  parameters:
    comment: in seconds, from inspectrum
    value: '0.5'
  states: {}
- name: stop_time
  id: variable
  parameters:
    comment: in seconds, from inspectrum
    value: '1.2'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: from inspectrum analysis
    value: '800'
  states: {}
- name: variable_low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 5e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: |-
      1111 1111 in binary with two's complement
      flips all bits in case the graph acquired the wrong symbol
    const: '-1'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: EOB
    false_value: 'False'
    true_key: SOB
    true_value: 'True'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      delay may be needed if bits don't align to message. 
      Valid delay range is 0 to 7.
    delay: '2'
    type: byte
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Answer should be:
      Well hello there! This is Demod 101 part 1. flag{0n_ofF_k3y1nG}
    file: /tmp/test.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test2.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dragon/Documents/GNU-Radio-Conference-2023-CTF/Demod101/demod.sigmf-data
    length: int((stop_time - start_time) * samp_rate)
    offset: int(start_time * samp_rate)
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/dragon/Documents/GNU-Radio-Conference-2023-CTF/Demod101/demod.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10e3
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '-8e3'
    init: '0'
    low: '-9e3'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '101010101010101010'
    tagname: frame_start
    threshold: '1'
    type: byte
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: int(samp_rate / (decimation * symbol_rate))
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, new_tag_value=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Editor',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.new_tag_value = new_tag_value
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0]
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tags:
                  key = pmt.to_python(tag.key) # convert from PMT to python string
                  value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                  print('key:', key)
                  print('value:', value, type(value))
                  print('')
                  if(value):
                      new_value = pmt.from_long(self.new_tag_value)
                      self.add_item_tag(0, # Write to output port 0
                                tag.offset, # Index of the tag in absolute terms
                                tag.key, # Key of the tag
                                new_value # Value of the tag
                       )
              return len(output_items[0])
    new_tag_value: '8400'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import array
      import numpy
      import scipy.signal

      tau = numpy.pi * 2
      max_samples = 1000000
      debug = True

      # determine the clock frequency
      # input: magnitude spectrum of clock signal (numpy array)
      # output: FFT bin number of clock frequency
      def find_clock_frequency(spectrum):
          maxima = scipy.signal.argrelextrema(spectrum, numpy.greater_equal)[0]
          while maxima[0] < 2:
              maxima = maxima[1:]
          if maxima.any():
              threshold = max(spectrum[2:-1])*0.8
              indices_above_threshold = numpy.argwhere(spectrum[maxima] > threshold)
              return maxima[indices_above_threshold[0]]
          else:
              return 0

      def midpoint(a):
          """
          @brief takes two sets of values, one set is all values above the mean and the other is all values below the mean.
                 then it finds the median of each set and returns the value in between the median of each set.
          """
          mean_a = numpy.mean(a)
          mean_a_greater = numpy.ma.masked_greater(a, mean_a)
          high = numpy.ma.median(mean_a_greater)
          mean_a_less_or_equal = numpy.ma.masked_array(a, ~mean_a_greater.mask)
          low = numpy.ma.median(mean_a_less_or_equal)
          midpoint_result = (high + low) / 2
          return midpoint_result

      # whole packet clock recovery                                                                                                                                         
      # input: real valued NRZ-like waveform (array, tuple, or list)                                                                                                        
      #        must have at least 2 samples per symbol                                                                                                                      
      #        must have at least 2 symbol transitions                                                                                                                      
      # output: list of symbols                                                                                                                                             
      def wpcr(a):                                                                                                                                                          
          if len(a) < 4:                                                                                                                                                    
              return []                                                                                                                                                     
                                                                                                                                                                            
          # input conditioning                                                                                                                                              
          b = (a > midpoint(a)) * 1.0 # convert samples into floats of 0 and 1. 0 if the sample is below the midpoint, 1 if it is above
          d = numpy.diff(b)**2        # find symbol transition points and mark with the value 1
          if len(numpy.argwhere(d > 0)) < 2:
              return []
          f = scipy.fft.fft(d, len(a))    # len(a) larger than len(d), so pad d with zeros and find clock frequency
          p = find_clock_frequency(abs(f))
          if p == 0:
              return []
          cycles_per_sample = (p*1.0)/len(f)
          clock_phase = 0.5 + numpy.angle(f[p])/(tau)
          if clock_phase <= 0.5:
              clock_phase += 1
          symbols = []
          for i in range(len(a)):
              if clock_phase >= 1:
                  clock_phase -= 1
                  symbols.append(a[i])
              clock_phase += cycles_per_sample
          if debug:
              print("peak frequency index: %d / %d" % (p, len(f)))
              print("samples per symbol: %f" % (1.0/cycles_per_sample))
              print("clock cycles per sample: %f" % (cycles_per_sample))
              print("clock phase in cycles between 1st and 2nd samples: %f" % (clock_phase))
              print("clock phase in cycles at 1st sample: %f" % (clock_phase - cycles_per_sample/2))
              print("symbol count: %d" % (len(symbols)))
          return symbols

      # convert soft symbols into bits (assuming binary symbols)
      def slice_bits(symbols):
          symbols_average = numpy.average(symbols)
          bits = (symbols >= symbols_average)
          return numpy.array(bits, dtype=numpy.uint8)



      class blk(gr.sync_block):
          """Packet Format"""

          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Packet Format GR38",
                  in_sig = None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out0'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)

          def handle_msg(self, msg):
              inMsg = pmt.to_python(msg)
              pld = inMsg[1] ## type-> numpy.ndarray
              mLen = len(pld)
              print(type(pld))
              if (mLen > 0):
                  symbols=wpcr(pld)
                  bits=slice_bits(symbols)
                  print(list(bits))
                  ## create PMT u8vector using byte array
                  #new_out_bytes_pmt=pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(new_bytes_out_len,(byte_array_new_char_list)))
                  self.message_port_pub(pmt.intern('PDU_out0'), msg)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: frequency_shift
    comment: |-
      Input Rate: samp_rate
      Output Rate: samp_rate / decimation
    decim: decimation
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    type: TCP_CLIENT
  states: {state: disabled}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: float
  states: {}
- name: pdu_tags_to_pdu_x_0
  id: pdu_tags_to_pdu_x
  parameters:
    end_tag: EOB
    max_pdu_size: max_pdu_size
    start_tag: SOB
    type: f
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"Before Quad Demod"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"BEFORE symbol sync"'
    size: int((stop_time - start_time) * (samp_rate / decimation))
    srate: samp_rate / decimation
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"AFTER symbol sync"'
    size: '8400'
    srate: symbol_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"AFTER symbol sync"'
    size: int((stop_time - start_time) * symbol_rate)
    srate: symbol_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"BEFORE symbol sync"'
    size: int((stop_time - start_time) * (samp_rate / decimation))
    srate: samp_rate / decimation
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"BEFORE symbol sync"'
    size: '48000'
    srate: samp_rate / decimation
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"BEFORE symbol sync"'
    size: '48000'
    srate: samp_rate / decimation
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"raw signal"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Before quad demod"'
    type: complex
  states: {state: disabled}
- name: sigmf_sink_0
  id: sigmf_sink
  parameters:
    append: 'False'
    author: ''
    description: ''
    field_10_key: ''
    field_10_type: string
    field_10_value: ''
    field_11_key: ''
    field_11_type: string
    field_11_value: ''
    field_12_key: ''
    field_12_type: string
    field_12_value: ''
    field_13_key: ''
    field_13_type: string
    field_13_value: ''
    field_14_key: ''
    field_14_type: string
    field_14_value: ''
    field_15_key: ''
    field_15_type: string
    field_15_value: ''
    field_16_key: ''
    field_16_type: string
    field_16_value: ''
    field_17_key: ''
    field_17_type: string
    field_17_value: ''
    field_18_key: ''
    field_18_type: string
    field_18_value: ''
    field_19_key: ''
    field_19_type: string
    field_19_value: ''
    field_1_key: ''
    field_1_type: string
    field_1_value: ''
    field_20_key: ''
    field_20_type: string
    field_20_value: ''
    field_21_key: ''
    field_21_type: string
    field_21_value: ''
    field_22_key: ''
    field_22_type: string
    field_22_value: ''
    field_23_key: ''
    field_23_type: string
    field_23_value: ''
    field_24_key: ''
    field_24_type: string
    field_24_value: ''
    field_25_key: ''
    field_25_type: string
    field_25_value: ''
    field_2_key: ''
    field_2_type: string
    field_2_value: ''
    field_3_key: ''
    field_3_type: string
    field_3_value: ''
    field_4_key: ''
    field_4_type: string
    field_4_value: ''
    field_5_key: ''
    field_5_type: string
    field_5_value: ''
    field_6_key: ''
    field_6_type: string
    field_6_value: ''
    field_7_key: ''
    field_7_type: string
    field_7_value: ''
    field_8_key: ''
    field_8_type: string
    field_8_value: ''
    field_9_key: ''
    field_9_type: string
    field_9_value: ''
    filename: /home/dragon/Documents/GNU-Radio-Conference-2023-CTF/Demod101/part1_beforesymbolsync.sigmf-data
    hardware: ''
    license: ''
    num_extra_fields: '0'
    samp_rate: samp_rate / decimation
    time_mode: gr_sigmf.sigmf_time_mode_relative
    type: f32
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '10e-3'
    type: float
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:4444
    timeout: '100'
    type: float
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_xor_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_delay_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_const_vxx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_add_const_vxx_0, '0', sigmf_sink_0, '0']
- [blocks_burst_tagger_0, '0', blocks_tag_debug_0, '0']
- [blocks_burst_tagger_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_burst_tagger_0, '0', epy_block_0, '0']
- [blocks_burst_tagger_0, '0', pdu_tags_to_pdu_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_delay_1, '0', blocks_burst_tagger_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_xor_xx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_short_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_xor_xx_0, '0', blocks_file_sink_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_delay_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [epy_block_0, '0', blocks_tag_debug_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [pdu_pdu_to_stream_x_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [pdu_pdu_to_stream_x_0, '0', zeromq_push_sink_0, '0']
- [pdu_tags_to_pdu_x_0, pdus, epy_block_1, PDU_in]
- [pdu_tags_to_pdu_x_0, pdus, network_socket_pdu_0, pdus]
- [pdu_tags_to_pdu_x_0, pdus, pdu_pdu_to_stream_x_0, pdus]
- [single_pole_iir_filter_xx_0, '0', blocks_threshold_ff_0, '0']
- [single_pole_iir_filter_xx_0, '0', qtgui_time_sink_x_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
